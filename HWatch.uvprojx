# Keil uVision project HWatch.uvprojx, settings and files
target HWatch Configuration (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HWatch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Bsp;.\Drivers;.\User\Config;.\User\Gui;.\User\Fonts;.\User\img;.\User\Gui\lvgl;.\User\Gui\lvgl\lvgl_driver;.\User\Gui_App;.\User\Stack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
    ./User/Gui/: GUI_Paint.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Drivers
    ./Drivers/: led.c key.c hdc1080.c ds1302.c pulsesensor.c adc.c spi.c lcd_1inch28.c ht2828.c w25q16.c sysinfo.c beep.c usart.c iic.c drivers.h
  group Bsp
    ./Bsp/: system.h stick.c
  group Config
    ./User/Config/: lcd_config.c device_config.c
  group Fonts
    ./User/Fonts/: hwatch_icons_font_16.c hwatch_icons_font_24.c hwatch_icons_font_26.c hwatch_icons_font_32.c font20.c
  group Gui_App
    ./User/Gui_App/: gui_about.c gui_main.c gui_manager.c gui_sysinfo.c gui_inc.h gui_apps.c hwatch_symbol_def.h gui_heart.c gui_games.c gui_calender.c gui_calc.c gui_setting_alarmclock.c gui_setting.c gui_setting_task.c gui_game_player.c gui_usb.c
  group Gui_Core
    ./User/Gui/lvgl/master/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ./User/Gui/lvgl/master/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./User/Gui/lvgl/master/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./User/Gui/lvgl/master/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./User/Gui/lvgl/master/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./User/Gui/lvgl/master/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ./User/Gui/lvgl/master/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group Gui_Drv
    ./User/Gui/lvgl/lvgl_driver/: lv_port_disp.c lv_port_indev.c lv_port_disp.h
    ./User/Gui/lvgl/: lv_conf.h
  group Stack
    ./User/Stack/: calculator.c utils.h
